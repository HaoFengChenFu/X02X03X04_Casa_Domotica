# Keil uVision project HTTP_Server.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./: main.c HTTP_Server.c HTTP_Server_CGI.c Arial12x12.h lcd.c lcd.h rtc.h rtc.c SNTP.c main.h SNTP.h Interrupciones.c PIR.c PIR.h Principal.c Principal.h Temp_Hum.c Temp_Hum.h adc.h adc.c ThTermostato.c ThTermostato.h LDR.c LDR.h Iluminacion.h Iluminacion.c Mando.c Mando.h PuertaGaraje.c PuertaGaraje.h flashLib.c flashLib.h pulsador.c pulsador.h modo_sleep.c modo_sleep.h Sismo.c Sismo.h Consumo.c Consumo.h
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif rtc.cgi rtc.cgx Temp.cgi Temp.cgx Humedad.cgi Humedad.cgx Ventilador.cgi Luminosidad.cgi Luminosidad.cgx Consumo.cgi Consumo.cgx Vacaciones.cgi
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=25000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.15.0, Network:CORE 7.15.0, Network:Interface:ETH 7.15.0, Network:Service:SNTP Client 7.15.0, Network:Service:Web Server Compact 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:I2C 2.10, CMSIS Driver:SPI 2.15, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:Flash 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:RTC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:SRAM 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:Startup 2.6.3
